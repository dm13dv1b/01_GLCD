# Keil uVision project GLCD.uvproj, settings and files
target GLCD (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: GLCD
  c flags: Optim=3 OneElfS=1
  c include: .\inc;.\src;.\inc\Core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: GLCD.sct
  group Source
    ./src/: main.c startup_stm32f4xx.s
  group GLCD source
    ./src/: delay.c ks0108.c
  group GLCD include
    ./inc/: delay.h font.h ks0108.h
